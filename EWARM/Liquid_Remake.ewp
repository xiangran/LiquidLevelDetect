# IAR project Liquid_Remake.ewp, settings and files
configuration Liquid_Remake (ARM, debug)
  General.OGChipSelectEditMenu: STM32G431CB ST STM32G431CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G431xx
  ICCARM.IExtraOptions: -f buildconfig.cfg
  ICCARM.CCIncludePath2: ../Core/Inc; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; D:\Proj\STM32G4Driver\STM32G4xx_HAL_Driver\Inc; D:\Proj\STM32G4Driver\STM32G4xx_HAL_Driver\Inc\Legacy; D:\Proj\STM32G4Driver\CMSIS\Device\ST\STM32G4xx\Include; D:\Proj\STM32G4Driver\CMSIS\Include; ..\App\Inc; ..\Middlewares\Trace\inc; ..\Middlewares\Shell\Plugins\log; D:\Proj\Proj_Components\shell; ..\Middlewares\Shell
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../Core/Inc
  OBJCOPY.OOCOutputFile: Liquid_Remake.hex
  ILINK.IlinkOutputFile: Liquid_Remake.out
  ILINK.IlinkIcfFile: stm32g431xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/App
    ../App/Src/: ad5160.c app.c app_queue.c clist.c cmd.c exception.c flash.c needle_temp_ctrl.c public.c ringbuffer.c
  group Application/EWARM
    ../Middlewares/Trace/fault_handler/iar/: cmb_fault.S
    C:/Users/xiang/OneDrive/文档/Framework/STM32CubeG4/Drivers/CMSIS/Device/ST/STM32G4xx/Source/Templates/iar/: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: adc.c dma.c freertos.c gpio.c main.c rtc.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c stm32g4xx_it.c usart.c
  group Drivers/CMSIS
    ../../STM32G4Driver/CMSIS/Device/ST/STM32G4xx/Source/Templates/: system_stm32g4xx.c
  group Drivers/STM32G4xx_HAL_Driver
    ../../STM32G4Driver/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_rtc.c stm32g4xx_hal_rtc_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_ll_adc.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/Shell
    ../../Proj_Components/shell/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c
    ../Middlewares/Shell/: shell_port.c
  group Middlewares/Shell/Plugins
    ../Middlewares/Shell/Plugins/log/: log.c
  group Middlewares/Trace
    ../Middlewares/Trace/: cm_backtrace.c
